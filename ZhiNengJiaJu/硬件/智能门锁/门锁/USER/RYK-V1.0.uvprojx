# Keil uVision project RYK-V1.0.uvprojx, settings and files
target RYK-V1.0 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: V1.0 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\time;..\SYSTEM\wdg;..\HARDWARE\KEY;..\HARDWARE\Other;..\HARDWARE\AS608;..\HARDWARE\USART3;..\HARDWARE\LCD;..\HARDWARE\Wk_Up;..\HARDWARE\ZW_user;..\HARDWARE\OLED;..\CORE;..\HARDWARE\IIC;..\HARDWARE\24CXX;..\HARDWARE\COUNT;..\HARDWARE\SJ;..\HARDWARE
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c main.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: Key.c
    ../HARDWARE/AS608/: as608.c
    ../HARDWARE/Wk_Up/: wkup.c
    ../HARDWARE/ZW_user/: zw_user.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/COUNT/: count.c
    ../HARDWARE/: PWM.c Servo.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
    ../SYSTEM/wdg/: wdg.c
    ../SYSTEM/time/: timer.c
    ../HARDWARE/USART3/: usart3.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_iwdg.c stm32f10x_tim.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_pwr.c
  group README
    ../: README.TXT
